# Keil uVision project Tetris.uvprojx, settings and files
target Tetris_pr (6160000::V6.16::ARMCLANG)
  device: MKL05Z32xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.15.1
  cpu: IRAM(0x1FFFFC00,0x00001000) IROM(0x00000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Tetris
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x1ffffc00 size 0x1000
  group src
    ./: spi.c spi.h main.c gpio.c gpio.h oled.c oled.h font.c font.h blocks.c blocks.h Area.c area.h tsi.c tsi.h frdm_bsp.h gpioa.c gpioa.h klaw.c klaw.h menu.c menu.h game.c game.h
software components: CMSIS:CORE 5.5.0, Device:Startup 1.0.0
